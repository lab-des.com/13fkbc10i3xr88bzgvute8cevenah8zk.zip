Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-18T16:26:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 18 16:26:43 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{551C60D4-ACA2-4620-94A8-A7CDF7115084}\ifc * Database version: 5507 * Database creation date: Fri Jan 18 16:26:42 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 18 16:26:42 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 18 16:26:43 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Eames plastic armchair DAL with seat cushion, CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL:Eames plastic armchair DAL with seat cushion:333548
In: Level 1
Material: Glide black, 03 aluminium polished, Textile hopsak blue moor 84, 01 basic dark
Pset_ManufacturerTypeInformation - ModelReference: 44036100; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.38773 m2; Volume: 0.310658 m3
Materials and Finishes - ChairMainMaterial: 01 basic dark; ChairQuaternaryMaterial: Glide black; ChairSecondaryMaterial: Textile hopsak blue moor 84
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL: Eames plastic armchair DAL with seat cushion; Family and Type: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL: Eames plastic armchair DAL with seat cushion; InstallationDate: n/a; Material: Polypropylene, aluminium & textile; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL: Eames plastic armchair DAL with seat cushion; Type Id: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL: Eames plastic armchair DAL with seat cushion; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Construction(Type) - SeatCushionVisibility: yes; SeatType: Eames_plastic_DAL_simplechair+cushion
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL; ConvergoRefNr: 0089-1812-0001-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The seat shells of the Eames Plastic Chairs can be combined with a variety of different bases. The base for the DAL chair (Dining Height Armchair La Fonda Base) was developed by Charles and Ray Eames in 1961 for the legendary New York restaurant La Fonda del Sol, whose interior was designed by their friend Alexander Girard.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 16/01/2019
Identity Data(Type) - Collection: Eames plastic armchair; Cost: 0; Description: The seat shells of the Eames Plastic Chairs can be combined with a variety of different bases. The base for the DAL chair (Dining Height Armchair La Fonda Base) was developed by Charles and Ray Eames in 1961 for the legendary New York restaurant La Fonda del Sol, whose interior was designed by their friend Alexander Girard. With its central pedestal consisting of four parallel shafts that split at the bottom to form a four-star base, it is one of the most elegant and unconventional bases ever designed by the Eameses.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames plastic armchair DAL with seat cushion; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/970265/storage/master/download/Factbook%20EPC-EN.pdf; Type Name: Eames plastic armchair DAL with seat cushion; URL: https://www.vitra.com/en-un/living/product/details/eames-plastic-armchair-dal
Materials and Finishes(Type) - ChairTertiaryMaterial: 03 aluminium polished
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_DAL; Features: Optional seat cushion or full upholstery.; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. Base: La Fonda base in polished die-cast aluminium. (DAL = Dining Height Armchair La Fonda Base); Grade: n/a; ModelNumber: n/a; ModelReference: 44036100; Name: DmstcChrs_Eames_PlasticArmchair_DAL_Cushion; ReplacementCost: n/a; Shape: Sculptured; Size: 630x605x815 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
